# Keil uVision project BTL.uvprojx, settings and files
target boot (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BTL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\main;.\IP_Layer\inc;.\Middleware_Layer\inc;.\Application_Layer\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application_Layer
    ./Application_Layer/inc/: bootloader.h
    ./Application_Layer/src/: bootloader.c
  group IP_Layer
    ./IP_Layer/inc/: ip_flash.h ip_uart.h
    ./IP_Layer/src/: ip_flash.c ip_uart.c
  group main
    ./main/: main.c main.h stm32f10x_conf.h assert.c
  group Middleware_Layer
    ./Middleware_Layer/inc/: crc.h protocol.h
    ./Middleware_Layer/src/: crc.c protocol.c
software components: CMSIS:CORE 5.4.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
